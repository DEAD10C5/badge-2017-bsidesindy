File: kicad/hh.kicad_pcb (KiCad board)
At the start: 2 copper layers, 169.7 x 51.9 mm, 1 part

Commit message: convert eagle to KiCAD
Other:
- net class Default removed
